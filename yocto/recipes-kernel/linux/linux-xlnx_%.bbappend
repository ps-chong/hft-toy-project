FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:hft-myd-czu5ev-v2 = " file://hft-openamp.cfg"
